Commit message: final exam prep done

File: ME553_2022/resource/cartPole/cartpole_double.urdf (robot description, URDF)
Before this commit: robot Cartpole, 5 links, 4 joints
Links:
- link sliderBar: geometry 
