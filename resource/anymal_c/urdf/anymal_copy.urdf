Commit message: final working copy

File: resource/anymal_c/urdf/anymal_copy.urdf (robot description, URDF)
Before this commit: robot anymal, 3 links, 2 joints
Links:
- link LF_HIP: mass 0.001 -> 0.01
- link base: mass None -> 2; geometry 
